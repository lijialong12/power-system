# Keil uVision project POWER_STM32407_FreeRTOS.uvprojx, settings and files
target POWER_STM32F407_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  AfterMake: $L\run.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\CONFIG;..\..\UserTask;..\..\Drivers\BSP\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Task
    ../../UserTask/: led_task.c dynsys_task.c hmi_task.c pump_task.c foot_task.c handle_task.c pc_task.c
  group Config
    ../../CONFIG/: includes.h FreeRTOSConfig.h nvicprio_conf.h task_conf.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_iwdg.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/IIC/: MYIIC.c 24cxx.c
    ../../Drivers/BSP/EXTI/: EXTI.c
    ../../Drivers/BSP/PWM/: PWM.c
    ../../Drivers/BSP/TIM/: TIM.c
    ../../Drivers/BSP/USART/: USART.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/TIM_PWM_DMA/: TIM1_CH3_DMA2_6_PWM.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/XMRAM
    ../../Middlewares/XMRAM/: XMRAM.h XMRAM.lib
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ../../: readme.txt
